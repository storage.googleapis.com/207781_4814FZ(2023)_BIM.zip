Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 66d3d2e8-1905-4209-b052-8e82af9957c2, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 4814FZ(2021).ifc
Time: 2024-10-18T18:49:46
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_351418_1
InPort_351418_2

# IfcFlowController: 4814FZ(2021):4814FZ Washbasin faucet, 6 V, Bluetooth, 4814FZ(2021):4814FZ Washbasin faucet, 6 V, Bluetooth:351418
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - General - Author: BIMStone; BIMObjectName: 4814FZ(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Kitchen faucet with high spout.; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - Approval KIWA SE Type Approval: 1745; EAN Number: 6414150097089; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: EN 15091, ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; ETIM Class Number: EC011328 Washbasin mixing tap; LVI Number: 6110341; Noise Class: I (ISO 3822); NRF Number: 4200281; RSK Number: 8430642; Sales Package dimensions (LxWxH): 290 x 210 x 90; STF Certificate: EUFI29-21003824-TH; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/4814FZ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/4814FZ; URL Materials Declaration: http://www.oras.com/fileadmin/resources/183057_4814FZ_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL STF: http://static.oras.com/STF/4814FZ; URL UN38.3: http://static.oras.com/UN383/4814FZ; URL UWL: http://static.oras.com/UWL/4814FZ; URL WEEE: http://static.oras.com/WEEE/4814FZ; VVS Number: 704214104
Type - Electrical - Battery: Lithium 2CR5 6 V; Bluetooth: 4.x (D034445); Operating Voltage: 6 V; Protection Class: IP 55
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Advanced Features: Inner body made of DZR brass;Software settings adjustable via App;Convertible for cold or premixed-water supply; Aerator: Hidden aerator;PCA® - constant flow rate regardless of pressure variations;Adjustable flow angle; Afterflow Period: 3 s (1-20 s); Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Electronic Parts: Autofocus infrared sensor;Solenoid valve;Low battery indicator; Excluded Items: Without pop-up waste; Flow Rate At 300kPa With Flow Controller: 0.08 dm3/s; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 C; Max Flow Period: 2 min (1 - 1800 s); Mechanical Parts: Mixing valve for manual temperature control;Non-return valve(s);Litter filter(s); Mounting Holes: 1 hole; Operating Distance: 20-130 mm (110/130/160 mm); Pressure Loss With Flow 01ls: 200000 Pa; Spout Projection: 105 mm; Spout Type: Fixed spout;Casted construction; Surface treatment: Chrome; Temperature Adjustments: Adjustable hot water stop (included, retrofittable); Working Pressure: 100 - 1000 kPa
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 153.2 mm; NominalHeight: 136 mm; NominalWidth: 65.1238 mm
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/4814FZ; 3D View: https://static.oras.com/3D/4814FZ; Ambience photo: http://static.oras.com/ambience/4814FZ; Catalog Drawing URL: http://static.oras.com/catdrw/4814FZ; Category B2C: Washbasin; Dimension Drawing URL: http://static.oras.com/dimdrw/4814FZ; FDV Document URL: http://www.oras.com/datasheet/4814FZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/4814FZ; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/4814FZ; Interactive AR View URL: https://static.oras.com/AR/4814FZ; Long Marketing: Touchless washbasin faucet, designed with the latest technology for a smart and seamless experience. This deck-mounted faucet features a touchless operation and Bluetooth® connectivity, allowing for easy control via the app. The temperature control handle offers precise water temperature adjustments, while touchless faucets are proven to reduce water consumption by up to 50%, making it an eco-friendly choice. The inner body is made of corrosion resistant brass, ensuring long-lasting performance. With software settings adjustable via app and convertible for cold or premixed-water supply, this faucet brings sustainability and is perfect for both public and semi-public washrooms. Choose flexibly between three operating modes, Adjust general faucet settings, Schedule automatic cleaning and flush mode.Upgrade to the Stela line for a perfect balance of design and technology.; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/4814FZ; Model: 4814FZ Washbasin faucet, 6 V, Bluetooth; Name_en: 4814FZ Washbasin faucet, 6 V, Bluetooth; OmniClass Number: 23.45.55.00; Product Code: 4814FZ; Product Family: Oras Stela ECO+; Product Image URL: http://static.oras.com/image/4814FZ; Product URL: http://static.oras.com/4814FZ; Replacement to: 2814F;2814FZ; Spare-Part Information URL: http://static.oras.com/sp/4814FZ; Technical DataSheet URL: http://www.oras.com/datasheet/4814FZ/en; Type Name: 4814FZ Washbasin faucet, 6 V, Bluetooth; Usage Group: Sweden; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 4814FZ(2021); Features: Touchless;Bluetooth®;Battery-operated; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 4814FZ; Name: 4814FZ Washbasin faucet, 6 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 65x155x135 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 4814FZ; Manufacturer: Oras
Type - Pset_ProductRequirements - Name: 4814FZ Washbasin faucet, 6 V, Bluetooth
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>, Brass
Pset_DistributionFlowElementCommon - Reference: 4814FZ Washbasin faucet, 6 V, Bluetooth; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Dimensions - Area: 0.0407627 m2; Volume: 0.00136132 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 4814FZ(2021); Family and Type: 4814FZ(2021): 4814FZ Washbasin faucet, 6 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 4814FZ Washbasin faucet, 6 V, Bluetooth; Type Id: 351402; WarrantyStartDate: n/a
